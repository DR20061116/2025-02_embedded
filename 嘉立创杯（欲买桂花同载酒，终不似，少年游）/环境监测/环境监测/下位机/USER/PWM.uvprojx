# Keil uVision project PWM.uvprojx, settings and files
target PWM (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\TIMER;..\HARDWARE\PWM;..\HARDWARE\KEY;..\NET\onenet\inc;..\NET\MQTT;..\NET\device\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\OLED;..\HARDWARE\DS18B20;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\LSENS;..\HARDWARE\KEY;..\HARDWARE\DHT11;..\HARDWARE\DS1302;..\HARDWARE\G90;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\LSENS;..\HARDWARE\DS18B20;..\HARDWARE\MAX30102;..\HARDWARE\MPU;..\HARDWARE\OLED;..\HARDWARE\MPU6050\Src;..\HARDWARE\MPU6050\Inc;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\KEY;..\HARDWARE\TIM;..\HARDWARE\AT24C02;..\HARDWARE\J_CON;..\HARDWARE\RC522;..\HARDWARE\ADCSensor;..\HARDWARE\STEPPERMOTOR;..\HARDWARE\DS18B20
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/J_CON/: jcon.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/ADCSensor/: ADCSensor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c
  group NET
    ../NET/device/src/: esp8266.c
    ../NET/onenet/src/: onenet.c base64.c hmac_sha1.c
    ../NET/MQTT/: MqttKit.c
