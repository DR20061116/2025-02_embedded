# Keil uVision project lcd.uvprojx, settings and files
target lcd (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lcd +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./Common;./Hardware/jy901s;./Hardware/GPS;./Hardware/LORA;./Hardware/Buzzer;./Hardware/LED;./Hardware/Ask;./Hardware/GY-906;./Hardware/LCD;./Use/fall;./Use/mylcd;./Hardware/Max30102;./Hardware/Key;./Use/jieshou;.\Hardware\mycode
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Common
    ./Common/: Com_debug.c Delay.c
  group Hardware
    ./Hardware/jy901s/: jy901s.c
    ./Hardware/GPS/: GPS.c
    ./Hardware/Buzzer/: Buzzer.c
    ./Hardware/LORA/: LORA.c
    ./Hardware/LED/: Int_led.c
    ./Hardware/Ask/: Ask.c
    ./Hardware/GY-906/: GY906.c
    ./Hardware/LCD/: lcd.c lcd_init.c
    ./Hardware/Max30102/: max30102.c spo2_algorithm.c
    ./Hardware/Key/: Key.c
    ./Hardware/mycode/: mycode.c mycode.h
  group Use
    ./Use/fall/: fall.c
    ./Use/mylcd/: mylcd.c
    ./Use/jieshou/: uart_receiver.c
software components: CMSIS:CORE 6.1.0
